IMAGE_FEATURES += " ssh-server-dropbear"
