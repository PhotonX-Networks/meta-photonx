IMAGE_FEATURES += " ssh-server-openssh"
